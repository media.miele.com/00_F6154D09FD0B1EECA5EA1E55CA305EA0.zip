Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-02-22T14:15:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 22 14:15:23 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\5adb1a09-58a9-4a42-966f-41d370a3f687\a68801e6-4723-4f95-b573-34e354059730\ifc * Database version: 5507 * Database creation date: Tue Feb 22 14:15:22 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 22 14:15:23 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 22 14:15:23 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11909130_USA_EBA2748_EDST:29992972_USA_11909130_EBA2748_EDST, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 29992972_USA_11909130_EBA2748_EDST
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 29992972_USA_11909130_EBA2748_EDST
Pset_BuildingElementProxyCommon - sets with these values: 2
